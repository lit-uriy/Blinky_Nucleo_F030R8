# Keil uVision project Blinky.uvprojx, settings and files
target STM32F030 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0-dev1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Files
    ./: Blinky.c stdout_USART.c
  group Documentation
    ./: Abstract.txt
target STM32F030 RAM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0-dev1
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x1000
software components: CMSIS:CORE 5.0.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Compiler:I/O:STDOUT 1.0.0, Device:Startup 2.2.3
